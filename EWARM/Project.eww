<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\bydcar_g491vet6.ewp</path>
  </project>
  <batchBuild />
</workspace>
